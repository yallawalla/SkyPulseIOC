# Keil uVision project SkyPulseNucleo.uvprojx, settings and files
target SkyPulseNucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SkyPulse +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx, __REENT=1
  c misc: --exceptions
  c include: ../Inc;                                                                                                            ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                                            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                                            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                                            ../Middlewares/Third_Party/FatFs/src;                                                                                                            ../Drivers/CMSIS/Include;                                                                                                            ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                                                                            ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                                                            ..\..\C\Inc;                                                                                                            ..\..\Cpp\Inc;                                                                                                            ..\..\lcd\src;                                                                       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                       ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c queue.c event_groups.c tasks.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/User
    ../Src/: main.c usbd_desc.c usbd_cdc_if.c user_diskio.c usb_device.c fatfs.c stm32f4xx_it.c stm32f4xx_hal_msp.c usbd_conf.c freertos.c stm32f4xx_hal_timebase_TIM.c
  group C
    ../../C/Src/: io.c proc.c retarget.c misc.c printf_stdarg.c
    ../../lcd/Objects/: lcd.lib
  group Cpp
    ../../Cpp/Src/: term.cpp ioc.cpp can.cpp adc.cpp pump.cpp fan.cpp cli.cpp spray.cpp ws2812.cpp rtc.cpp fit.cpp
    ../../: info.txt
software components: CMSIS:CORE 5.0.1
